# Keil uVision project template.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: template +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: .\User;.\Libraries\CMSIS;.\Driver\STM32F10x_StdPeriph_Driver\inc;.\Driver\DELAY;.\Driver\Usart;.\Driver\2.8 TFTLCD ST7789V
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group user
    ./User/: main.c
    ./User/Interrupt/: stm32f10x_it.c
  group Driver
    ./Driver/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_dma.c stm32f10x_spi.c stm32f10x_usart.c stm32f10x_exti.c
    ./Driver/DELAY/: delay.c
    ./Driver/Usart/: usart.c
    ./Driver/2.8 TFTLCD ST7789V/: st7789v.c
  group Libraries
    ./Libraries/CMSIS/: core_cm3.c system_stm32f10x.c startup_stm32f10x_hd.s
